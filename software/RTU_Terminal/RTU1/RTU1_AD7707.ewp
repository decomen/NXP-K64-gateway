# IAR project RTU1_AD7707.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK64F12; CLOCK_SETUP=6; LITTLE_EDIAN
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe188
  ICCARM.CCIncludePath2: ; ..\rt-thread\include; ..\threaddog; ..\drivers; ..\drivers\zigbee; ..\drivers\gprs; ..\drivers\varmanage; ..\drivers\protomanage; ..\drivers\cJSON; ..\drivers\in_out; ..\drivers\ad7707; board; applications; applications\test; ..\board; ..\applications; ..\applications\test; ..\board\cfg; ..\board\drv; ..\rt-thread\libcpu\arm\cortex-m4; ..\rt-thread\components\drivers\include; ..\rt-thread\components\drivers\spi; ..\rt-thread\libcpu\arm\common; ..\rt-thread\components\finsh; ..\rt-thread\components\dfs\include; ..\rt-thread\components\dfs\filesystems\elmfat; ..\rt-thread\components\dfs\filesystems\romfs; ..\libraries\startup\CoreSupport; ..\libraries\startup\DeviceSupport; ..\libraries\drivers\K\inc; ..\libraries\devices\inc; ..\rt-thread\components\net\freemodbus; ..\rt-thread\components\net\freemodbus\port; ..\rt-thread\components\net\freemodbus\modbus\include; ..\rt-thread\components\net\freemodbus\modbus\rtu; ..\rt-thread\components\net\freemodbus\modbus\tcp; ..\rt-thread\components\net\freemodbus\modbus\ascii; ..\rt-thread\components\net\lwip-1.4.1\src; ..\rt-thread\components\net\lwip-1.4.1\src\include; ..\rt-thread\components\net\lwip-1.4.1\src\include\ipv4; ..\rt-thread\components\net\lwip-1.4.1\src\include\netif; ..\rt-thread\components\net\lwip-1.4.1\src\include\lwip; ..\rt-thread\components\net\lwip-1.4.1\src\core; ..\rt-thread\components\net\lwip-1.4.1\src\core\ipv4; ..\rt-thread\components\net\lwip-1.4.1\src\api; ..\rt-thread\components\net\lwip-1.4.1\src\arch\include; ..\rt-thread\components\net\webnet; ..\rt-thread\components\net\ftpd; ..\rt-thread\components\net\httpclient; ..\rt-thread\components\dfs\filesystems\nfs; ..\rt-thread\components\utilities\logtrace; ..\rt-thread\components\external\SQLite-3.8.1\SQLiteLib; ..\rt-thread\components\external\SQLite-3.8.7; ..\rt-thread\components\external\lua-5.3.3\src; ..\drivers\sx1278; ..\reg; ..\rt-thread\components\external\mxml; ..\rt-thread\components\external\aes; ..\rt-thread\components\external\iniparser; ..\rt-thread\components\external\sntp; ..\rt-thread\components\external\expression; ..\rt-thread\components\external\easylogger\inc; ..\rt-thread\components\external\easylogger\plugins\flash; ..\rt-thread\components\external\easylogger\port; ..\sdccp; drivers\gprs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTU1_AD7707.bin
  ILINK.IlinkOutputFile: RTU1_AD7707.out
  ILINK.IlinkIcfFile: config\MK64xN1M_12_Update.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c startup.c
  group Applications/test
    ../applications/test/: bytebuffer.h mdcrc32.c mdcrc32.h mdcrc8.c mdcrc8.h mdtypedef.h
    applications/test/: sdccp.h sdccp_test.h server_com.c server_com.h test.c test.h
  group Board
    board/: board.c
    ../board/: board_udp.c cpu_usage.c file_retarget.c net_helper.c rtcrc32.c storage.c time.c update.c xfer_dst_serial.c xfer_helper.c xfer_net.c zgb_std.c
    ../rt-thread/components/net/freemodbus/port/: user_mb_app.c user_mb_app_m.c
  group Board/Cfg
    ../board/cfg/: analog_cfg.c auth_cfg.c board_cfg.c dev_cfg.c dido_cfg.c gprs_cfg.c host_cfg.c net_cfg.c tcpip_cfg.c uart_cfg.c ws_cfg.c xfer_cfg.c zigbee_cfg.c
  group Board/Drv
    ../board/drv/: drv_enet_phy.c drv_pin.c drv_rtc.c drv_sd.c drv_spi.c drv_uart.c
  group Board/Lua
    ../board/lua/: lrtu.c lrtu_didolib.c lrtu_sys.c lrtu_uart.c lua_mem.c
  group Config
    board/: board.h
    ../board/cfg/: board_cfg.h
    ./: rtconfig.h
  group Device
    ../libraries/startup/DeviceSupport/IAR-ARM/: startup_MK64F12.s
    ../libraries/startup/DeviceSupport/: system_MK64F12.c
  group Drivers/ad7707
    ../drivers/ad7707/: ad7707.c ad7707.h
  group Drivers/cJSON
    ../drivers/cjson/: cJSON.c
  group Drivers/GPRS
    drivers/gprs/: gprs_helper.c
  group Drivers/in_out
    ../drivers/in_out/: in_out.c in_out.h
  group Drivers/protomanage
    ../drivers/protomanage/: protomanage.c
  group Drivers/SX1278
    ../drivers/sx1278/: radio.c radio.h spi_hal.c spi_hal.h sx1276-Fsk.c sx1276-Fsk.h sx1276-FskMisc.c sx1276-FskMisc.h sx1276-Hal.c sx1276-Hal.h sx1276-LoRa.c sx1276-LoRa.h sx1276-LoRaMisc.c sx1276-LoRaMisc.h sx1276.c sx1276.h
  group Drivers/Varmanage
    ../drivers/varmanage/: varmanage.c varmanage.h
  group Drivers/Zigbee
    ../drivers/zigbee/: zigbee.c
  group Firmware
    ../libraries/drivers/K/src/: common.c dma.c enet.c flash.c gpio.c rtc.c sd.c spi.c uart.c wdog.c
    ../libraries/devices/src/: enet_phy.c
  group reg
    ../reg/: rtu_crc32.c rtu_des.c rtu_md5.c rtu_reg.c rtu_sha.c
  group RT-Thread/Components/aes
    ../rt-thread/components/external/aes/: aes.c aes.h
  group RT-Thread/Components/Dfs/Elmfat
    ../rt-thread/components/dfs/filesystems/elmfat/option/: cc936.c ccsbcs.c
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group RT-Thread/Components/Dfs/Nfs
    ../rt-thread/components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
    ../rt-thread/components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
  group RT-Thread/Components/Dfs/Romfs
    ../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group RT-Thread/Components/easylogger/inc
    ../rt-thread/components/external/easylogger/inc/: elog.h elog_cfg.h
  group RT-Thread/Components/easylogger/port
    ../rt-thread/components/external/easylogger/port/: elog_port.c
  group RT-Thread/Components/easylogger/src
    ../rt-thread/components/external/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group RT-Thread/Components/expression
    ../rt-thread/components/external/expression/: exp_parser.c tokenizer.c
  group RT-Thread/Components/Finsh
    ../rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group RT-Thread/Components/Freemodbus
    ../rt-thread/components/net/freemodbus/modbus/rtu/: mbcrc.c
    ../rt-thread/components/net/freemodbus/port/: port.c
  group RT-Thread/Components/Freemodbus/Config
    ../rt-thread/components/net/freemodbus/modbus/include/: mbconfig.h
  group RT-Thread/Components/Freemodbus/Master/Modbus
    ../rt-thread/components/net/freemodbus/modbus/: mb_m.c
    ../rt-thread/components/net/freemodbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
  group RT-Thread/Components/Freemodbus/Master/Modbus/ASCII
    ../rt-thread/components/net/freemodbus/modbus/ascii/: mbascii_m.c
  group RT-Thread/Components/Freemodbus/Master/Modbus/RTU
    ../rt-thread/components/net/freemodbus/modbus/rtu/: mbrtu_m.c
  group RT-Thread/Components/Freemodbus/Master/Modbus/TCP
    ../rt-thread/components/net/freemodbus/modbus/tcp/: mbtcp_m.c
  group RT-Thread/Components/Freemodbus/Master/Port
    ../rt-thread/components/net/freemodbus/port/: portevent_m.c portserial_m.c porttimer_m.c
  group RT-Thread/Components/Freemodbus/Slave/Modbus
    ../rt-thread/components/net/freemodbus/modbus/: mb.c
    ../rt-thread/components/net/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group RT-Thread/Components/Freemodbus/Slave/Modbus/ASCII
    ../rt-thread/components/net/freemodbus/modbus/ascii/: mbascii.c
  group RT-Thread/Components/Freemodbus/Slave/Modbus/RTU
    ../rt-thread/components/net/freemodbus/modbus/rtu/: mbrtu.c
  group RT-Thread/Components/Freemodbus/Slave/Modbus/TCP
    ../rt-thread/components/net/freemodbus/modbus/tcp/: mbtcp.c
  group RT-Thread/Components/Freemodbus/Slave/Port
    ../rt-thread/components/net/freemodbus/port/: portevent.c portserial.c porttcp.c porttimer.c
  group RT-Thread/Components/Ftpd
    ../rt-thread/components/net/ftpd/: ftp_request.c ftp_session.c ftpd.c
  group RT-Thread/Components/httpclient
    ../rt-thread/components/net/httpclient/: httpclient.c
  group RT-Thread/Components/ini
    ../rt-thread/components/external/iniparser/: iniparser.c
  group RT-Thread/Components/libc
    ../rt-thread/components/libc/dlib/: environ.c rmtx.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group RT-Thread/Components/libc/newlib
    ../rt-thread/components/libc/newlib/: libc.c syscalls.c
  group RT-Thread/Components/lua5.14/src
    ../rt-thread/components/external/lua-5.1.4/src/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lrotable.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lvm.c lzio.c print.c
  group RT-Thread/Components/lua5.3.3/src
    ../rt-thread/components/external/lua-5.3.3/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group RT-Thread/Components/Lwip/Api
    ../rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group RT-Thread/Components/Lwip/Arch
    ../rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group RT-Thread/Components/Lwip/Core
    ../rt-thread/components/net/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group RT-Thread/Components/Lwip/Netif
    ../rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group RT-Thread/Components/minixml/inc
    ../rt-thread/components/external/mxml/: mxml-config.h mxml-private.h mxml.h
  group RT-Thread/Components/minixml/src
    ../rt-thread/components/external/mxml/: mxml-attr.c mxml-entity.c mxml-file.c mxml-get.c mxml-index.c mxml-node.c mxml-private.c mxml-search.c mxml-set.c mxml-string.c
  group RT-Thread/Components/sntp
    ../rt-thread/components/external/sntp/: sntp.c
  group RT-Thread/Components/sqlite
    ../rt-thread/components/external/SQLite-3.8.7/: sqlite3.c
  group RT-Thread/Components/webnet
    ../rt-thread/components/net/webnet/: mimetype.c module.c request.c session.c util.c webnet.c webnet.h
  group RT-Thread/Components/webnet/module
    ../rt-thread/components/net/webnet/module/: webnet_auth.c webnet_cgi.c
  group RT-Thread/Components/webnet/websocket
    ../rt-thread/components/net/webnet/: base64.c sha1.c websocket.c ws_vm.c
  group RT-Thread/Components/zmodel
    ../rt-thread/components/utilities/zmodem/: rz.c sz.c zcore.c zdevice.c zstart.c
  group RT-Thread/CORTEX-M4
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group RT-Thread/DeviceDrives/Misc
    ../rt-thread/components/drivers/misc/: pin.c
  group RT-Thread/DeviceDrives/Rtc
    ../rt-thread/components/drivers/rtc/: rrtc.c
  group RT-Thread/DeviceDrives/Serial
    ../rt-thread/components/drivers/serial/: serial.c
  group RT-Thread/DeviceDrives/Spi
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
  group RT-Thread/DeviceDrives/Src
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group RT-Thread/Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group sdccp
    ../sdccp/: cc_bjdc.c cc_md5.c dlt645.c hjt212.c sdccp_net.c sdccp_serial.c
  group threaddog
    ../threaddog/: threaddog.c threaddog.h
