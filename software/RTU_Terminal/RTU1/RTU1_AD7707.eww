<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RTU1_AD7707.ewp</path>
  </project>
  <batchBuild/>
</workspace>


