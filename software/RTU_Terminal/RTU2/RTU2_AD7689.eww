<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RTU2_AD7689.ewp</path>
  </project>
  <batchBuild/>
</workspace>


